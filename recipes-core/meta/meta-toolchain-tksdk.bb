TOOLCHAIN_SUFFIX ?= "-tisdk"

require meta-toolchain-tksdk.inc
require recipes-core/meta/meta-toolchain-arago-qte.bb


PR = "${INC_PR}.0"

