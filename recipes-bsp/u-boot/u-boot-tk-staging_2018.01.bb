require u-boot-tk.inc

PR = "r18"

SRCREV = "5b2e79eb65589ec19caa4aeb26218ea3dccad038"
